# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\STM32F4xx_DSP_StdPeriph_Lib_V1.4.0\Libraries\CMSIS;.\STM32F4xx_DSP_StdPeriph_Lib_V1.4.0\Libraries\CMSIS\Include;.\user\inc;.\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./STM32F4xx_DSP_StdPeriph_Lib_V1.4.0/Libraries/CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ./user/src/: mian.c LED.c wang_time.c BEEP.c key.c redThink.c fireCheck.c usart.c nvic.c selfprintf.c exti.c systick.c baseTIM.c GeneralTim.c functions.c adc.c RNG.c event_handler.c iic.c at24c02.c spi.c w25q64.c iwdg.c rtc.c DMA.c
    ./user/inc/: LED.h wang_time.h BEEP.h key.h redThink.h fireCheck.h usart.h nvic.h selfprintf.h exti.h systick.h baseTIM.h GeneralTim.h functions.h adc.h RNG.h event_handler.h iic.h at24c02.h spi.h w25q64.h iwdg.h rtc.h DMA.h
